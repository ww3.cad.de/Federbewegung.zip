# Autodesk Inventor assembly: Federtest
## iProperties
Created: 2009-04
Part Number: Federtest
Document SubType Name: Assembly
Designer: Hans-Jürgen Eicke
Author: Hans-Jürgen Eicke
